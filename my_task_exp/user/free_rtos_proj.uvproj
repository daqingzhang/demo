# Keil uVision project free_rtos_proj.uvproj, settings and files
target free_rtos_proj (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: free_rtos_prj
  AfterMake: fromelf --bin --output ../Bin/free_rtos_prj.bin ../Output/free_rtos_prj.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, RVDS_ARMCM3_LM3S102,STM32F10X_HD
  c misc: --c99
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\FreeRTOS\Config;..\FreeRTOS\Source\include;..\BSP;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group FWlib
    ./: stm32f10x_it.c
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group freeRTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
  group BSP
    ../BSP/: dev_usart.c dev_usart.h dev_key.h dev_key.c dev_led.c dev_led.h
  group APP
    ./: my_task_exp.c task_main.c
